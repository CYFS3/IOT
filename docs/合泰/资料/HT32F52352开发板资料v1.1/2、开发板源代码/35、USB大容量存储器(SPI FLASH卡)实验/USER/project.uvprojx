# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: HT32F52352_64LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.32
  cpu: IROM(0x00000000,0x1FE00) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\CORE;..\HARDWARE;..\HT32F5x_FWLib;..\SYSTEM;..\USER;..\HT32F5x_FWLib\HT32F5xxxx_Driver\inc;..\HT32F5x_FWLib\HT32_USBD_Library\inc;..\HT32F5x_FWLib\Device\Holtek\HT32F5xxxx\Include;..\HT32F5x_FWLib\CMSIS\Include;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\BMP;..\HT32F5x_FWLib\HT32_USBD_Library\inc;..\USB
  asm define: USE_HT32F52342_52,USE_HT32_CHIP=4
  asm include: ..\CORE;..\HARDWARE;..\HT32F5x_FWLib;..\SYSTEM;..\USER;..\HT32F5x_FWLib\HT32F5xxxx_Driver\inc;..\HT32F5x_FWLib\HT32_USBD_Library\inc;..\HT32F5x_FWLib\Device\Holtek\HT32F5xxxx\Include;..\HT32F5x_FWLib\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c ht32f5xxxx_01_it.c
    ../HT32F5x_FWLib/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_01.c
  group HARDWARE
    ../HARDWARE/: key.c lcd.c flash.c sd.c spi.c
  group SYSTEM
    ../SYSTEM/: delay.c usart.c
  group CORE
    ../HT32F5x_FWLib/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f5xxxx_01.s
  group FWLib
    ../HT32F5x_FWLib/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group TXT
    ../TEXT/: fontupd.c text.c
  group USB
    ../USB/: ht32f5xxxx_01_usbdconf.h ht32_usbd_class.c ht32_usbd_descriptor.c usb_bulk_only_transport.c usb_scsi_block_command.c sd_disk.c
    ../HT32F5x_FWLib/HT32_USBD_Library/src/: ht32_usbd_core.c
  group FATS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: fattester.c exfuns.c mycc936.c
